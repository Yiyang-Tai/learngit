<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.14'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>sdrcourse_framer</key>
<param><key>id</key><value>sdrcourse_framer_0</value></param>
<param><key>blocksize</key><value>1024</value></param>
</block>
<block>
<key>sdrcourse_preamble_insert</key>
<param><key>id</key><value>sdrcourse_preamble_insert_0</value></param>
<param><key>preamble</key><value>[0,0,0,0,0,0,1,1,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,0]</value></param>
</block>
<block>
<key>sdrcourse_random_sourcecd</key>
<param><key>id</key><value>sdrcourse_random_sourcecd_0</value></param>
<param><key>bits_ratio</key><value>0.5</value></param>
<param><key>payload_length</key><value>100</value></param>
</block>
<block>
<key>sdrcourse_start_pending</key>
<param><key>id</key><value>sdrcourse_start_pending_0</value></param>
<param><key>start_next_time_s</key><value>5</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
</block>
<block>
<key>sdrcourse_symbol_mapper</key>
<param><key>id</key><value>sdrcourse_symbol_mapper_0</value></param>
<param><key>modtype</key><value>sdrcourse.BPSK</value></param>
<param><key>symbol_values</key><value>[0,1]</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>sdrcourse_start_pending_0</sink_block_id><source_key>strobe</source_key><sink_key>MSG</sink_key></connection>
<connection><source_block_id>sdrcourse_framer_0</source_block_id><sink_block_id>sdrcourse_preamble_insert_0</sink_block_id><source_key>OUT</source_key><sink_key>IN</sink_key></connection>
<connection><source_block_id>sdrcourse_preamble_insert_0</source_block_id><sink_block_id>sdrcourse_symbol_mapper_0</sink_block_id><source_key>OUT</source_key><sink_key>IN</sink_key></connection>
<connection><source_block_id>sdrcourse_random_sourcecd_0</source_block_id><sink_block_id>sdrcourse_framer_0</sink_block_id><source_key>OUT</source_key><sink_key>IN</sink_key></connection>
<connection><source_block_id>sdrcourse_start_pending_0</source_block_id><sink_block_id>sdrcourse_random_sourcecd_0</sink_block_id><source_key>OUT</source_key><sink_key>IN</sink_key></connection>
</flow_graph>
