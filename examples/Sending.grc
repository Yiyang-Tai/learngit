<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.14'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_per_symbol</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>0.6</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_tagged_stream_multiply_length</key>
<param><key>id</key><value>blocks_tagged_stream_multiply_length_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>c</key><value>1</value></param>
<param><key>lengthtagname</key><value>"packet_len"</value></param>
</block>
<block>
<key>digital_burst_shaper_xx</key>
<param><key>id</key><value>digital_burst_shaper_xx_0</value></param>
<param><key>insert_phasing</key><value>False</value></param>
<param><key>length_tag_name</key><value>"packet_len"</value></param>
<param><key>post_padding</key><value>0</value></param>
<param><key>pre_padding</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>window</key><value>gnuradio.fft.window.hanning(1024)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import gnuradio.digital</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>sdrcourse_crc_add</key>
<param><key>id</key><value>sdrcourse_crc_add_0</value></param>
</block>
<block>
<key>sdrcourse_mix</key>
<param><key>id</key><value>sdrcourse_mix_0</value></param>
</block>
<block>
<key>sdrcourse_preamble_insert</key>
<param><key>id</key><value>sdrcourse_preamble_insert_0</value></param>
<param><key>preamble</key><value>[0,0,0,0,0,0,1,1,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,0]</value></param>
</block>
<block>
<key>sdrcourse_pulse_shaper</key>
<param><key>id</key><value>sdrcourse_pulse_shaper_0</value></param>
<param><key>interpolation</key><value>1</value></param>
<param><key>taps</key><value>[0.68,0.60,0.52,0.43,0.34,0.26,0.19,0.12,0.05,0.00]</value></param>
</block>
<block>
<key>sdrcourse_random_sourcecd</key>
<param><key>id</key><value>sdrcourse_random_sourcecd_0</value></param>
<param><key>bits_ratio</key><value>0.5</value></param>
<param><key>payload_length</key><value>100</value></param>
</block>
<block>
<key>sdrcourse_start_pending</key>
<param><key>id</key><value>sdrcourse_start_pending_0</value></param>
<param><key>start_next_time_s</key><value>5</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
</block>
<block>
<key>sdrcourse_symbol_mapper</key>
<param><key>id</key><value>sdrcourse_symbol_mapper_1</value></param>
<param><key>modtype</key><value>sdrcourse.BPSK</value></param>
<param><key>symbol_values</key><value>[0,1]</value></param>
</block>
<block>
<key>sdrcourse_symbol_mapper</key>
<param><key>id</key><value>sdrcourse_symbol_mapper_2</value></param>
<param><key>modtype</key><value>sdrcourse.BPSK</value></param>
<param><key>symbol_values</key><value>[0,1]</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>0</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>sdrcourse_start_pending_0</sink_block_id><source_key>strobe</source_key><sink_key>MSG</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>digital_burst_shaper_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>sdrcourse_pulse_shaper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_multiply_length_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_burst_shaper_xx_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sdrcourse_crc_add_0</source_block_id><sink_block_id>sdrcourse_symbol_mapper_2</sink_block_id><source_key>out</source_key><sink_key>IN</sink_key></connection>
<connection><source_block_id>sdrcourse_mix_0</source_block_id><sink_block_id>sdrcourse_preamble_insert_0</sink_block_id><source_key>out</source_key><sink_key>IN</sink_key></connection>
<connection><source_block_id>sdrcourse_preamble_insert_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>OUT</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>sdrcourse_pulse_shaper_0</source_block_id><sink_block_id>blocks_tagged_stream_multiply_length_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sdrcourse_random_sourcecd_0</source_block_id><sink_block_id>sdrcourse_crc_add_0</sink_block_id><source_key>OUT</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>sdrcourse_start_pending_0</source_block_id><sink_block_id>sdrcourse_random_sourcecd_0</sink_block_id><source_key>OUT</source_key><sink_key>IN</sink_key></connection>
<connection><source_block_id>sdrcourse_start_pending_0</source_block_id><sink_block_id>sdrcourse_symbol_mapper_1</sink_block_id><source_key>OUT</source_key><sink_key>IN</sink_key></connection>
<connection><source_block_id>sdrcourse_symbol_mapper_1</source_block_id><sink_block_id>sdrcourse_mix_0</sink_block_id><source_key>OUT</source_key><sink_key>in_h</sink_key></connection>
<connection><source_block_id>sdrcourse_symbol_mapper_2</source_block_id><sink_block_id>sdrcourse_mix_0</sink_block_id><source_key>OUT</source_key><sink_key>in_p</sink_key></connection>
</flow_graph>
